# Keil uVision project SE-PU.uvproj, settings and files
target UKEY_FINGER_MH1901 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UKEY_FINGER_MH1901 +hex
  c flags: Optim=1 oTime=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\MCU_Libraries\Device\MegaHunt\mhscpu\Include;..\MCU_Libraries\CMSIS\Include;..\MCU_Libraries\MHSCPU_Driver\inc;..\MCU_Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Core\inc;..\MCU_Libraries\SCPU_USB_Lib\SCPU_USB_OTG_Driver\inc;..\MCU_Libraries\SCPU_USB_Lib\SCPU_USB_Device_Library\Class\msc\inc;..\Application\User;..\Application\BSP\inc;..\Application\logic;..\Application\usb;..\Application\cos;..\MCU_Libraries\MHSCPU_Driver\lib\securelib
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\SE-PU\Obj\SE-PU.sct
  group User
    ../Application/User/: main.c app_cmd.c
    ../Application/BSP/src/: board.c timer.c uart.c
  group Startup
    ../MCU_Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group MHSCPU_Driver
    ../MCU_Libraries/MHSCPU_Driver/src/: mhscpu_exti.c mhscpu_gpio.c mhscpu_sysctrl.c mhscpu_timer.c mhscpu_uart.c misc.c mhscpu_it.c mhscpu_flash.c mh_rand.c
  group CMSIS
    ../MCU_Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group USB
    ../Application/usb/: usbd_desc.c usb_bsp.c usbd_storage_msd.c usbd_usr.c
  group SCPU_USB_CORE_DRIVER
    ../MCU_Libraries/SCPU_USB_Lib/SCPU_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group SCPU_USB_Device_lib
    ../MCU_Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../MCU_Libraries/SCPU_USB_Lib/SCPU_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group COS
    ../MCU_Libraries/MHSCPU_Driver/lib/: crypt_lib.lib
    ../Application/cos/: cos.c hal_alg.c hal_flash_interface.c
target RAM-JLINK (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\..\..\Libraries\Device\MegaHunt\mhscpu\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\MHSCPU_Driver\inc;..\..\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
